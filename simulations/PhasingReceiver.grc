options:
  parameters:
    author: KQ7B
    description: 'Simulation of a phasing (no AGC, noise reduction, notch, etc) SSB receiver using Weaver method with complex/float data.  The data file source is from https://www.csun.edu/~skatz/katzpage/sdr_project/sdr/ssb_lsb_256k_complex2.dat.zip '
    generate_options: qt_gui
    id: PhasingSSBReceiver
    output_language: python
    title: Phasing SSB Receiver
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: decim
  id: variable
  parameters:
    value: (int)(samp_rate/audio_rate)
  states: {}
- name: nTaps
  id: variable
  parameters:
    value: '11'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    start: '0.0'
    step: '0.00001'
    stop: '0.001'
    value: '0.00001'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '3000'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_float_1
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_1
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ssb_lsb_256k_complex2.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: filter_delay_fc_0
  id: filter_delay_fc
  parameters:
    taps: nTaps
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '50000'
    decim: decim
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,3000,100)
    type: ccc
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: nTaps
  states: {}
- name: note_0
  id: note
  parameters:
    note: Decimate by 8 to convert the 256k source rate to the 32K audio sink rate
  states: {}
- name: note_1
  id: note
  parameters:
    note: Delay to match lower path
  states: {}
- name: note_2
  id: note
  parameters:
    note: Separate cos/sin outputs from sig src
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_complex_to_float_1, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_float_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_float_0, '1', blocks_multiply_xx_1, '0']
- [blocks_complex_to_float_1, '0', blocks_multiply_xx_0, '0']
- [blocks_complex_to_float_1, '1', blocks_multiply_const_vxx_1, '0']
- [blocks_complex_to_imag_0, '0', blocks_add_xx_0, '1']
- [blocks_complex_to_real_1, '0', blocks_add_xx_0, '0']
- [blocks_file_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', filter_delay_fc_0, '0']
- [blocks_multiply_xx_1, '0', hilbert_fc_0, '0']
- [filter_delay_fc_0, '0', blocks_complex_to_real_1, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_float_0, '0']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.2.0
